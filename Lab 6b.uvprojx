# Keil uVision project Lab 6b.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab 6b
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRINTF_FLOAT_ENABLE
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: 3140.s 3140_concur.c 3140_concur.h realtime.h utils.c utils.h process.c shared_structs.h main_t1.c main_t2.c main_t3.c
software components: CMSIS:CORE 5.0.1, Device:KSDK Configuration:FRDM-K64F 1.2.0, Device:KSDK Driver:GPIO 1.2.0, Device:KSDK Driver:RTC 1.2.0, Device:KSDK HAL:GPIO 1.2.0, Device:KSDK HAL:LPTMR 1.2.0, Device:KSDK HAL:MCG 1.2.0, Device:KSDK HAL:OSC 1.2.0, Device:KSDK HAL:PORT 1.2.0, Device:KSDK HAL:RTC 1.2.0, Device:KSDK HAL:SIM 1.2.0, Device:KSDK HAL:UART 1.2.0, Device:KSDK OSA:OSA 1.2.0, Device:KSDK System:Clock 1.2.0, Device:KSDK System:Interrupt 1.2.0, Device:KSDK Utility:Debug Console 1.2.0, Device:Startup 2.8
